# Keil uVision project FOC.uvprojx, settings and files
target FOC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;                       ../Drivers/STM32F1xx_HAL_Driver/Inc;                       ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                       ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                       ../Drivers/CMSIS/Include;                       ..\User\RTT;                       ..\User\Function;                       ..\User\FarmeWork;                       ..\User\MCUDriver;                       ..\User\PeripheralDriver;                       ..\User\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group User/APP
    ../User/APP/: APPMain.c APPMain.h
  group User/MCUDriver
    ../User/MCUDriver/: MCUDriverMain.c MCUDriverMain.h MotorGPIO.c MotorGPIO.h MotorHALSensor.c MotorHALSensor.h
  group User/PeripheralDriver
    ../User/PeripheralDriver/: PeripheralDriverMain.c PeripheralDriverMain.h
  group User/FarmeWork
    ../User/FarmeWork/: FarmeWorkMain.c FarmeWorkMain.h FOC.c FOC.h
  group User/Function
    ../User/Function/: FunctionMain.c FunctionMain.h FOCFunction.c FOCFunction.h
software components: CMSIS:CORE 4.3.0
